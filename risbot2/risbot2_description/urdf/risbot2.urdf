Commit message: [FIX] Kinematics

File: risbot2/risbot2_description/urdf/risbot2.urdf (robot description, URDF)
Before this commit: robot risbot2, 7 links, 6 joints
Joints:
- joint scan_joint: origin xyz=0.2 0 0.195722 rpy=0 0 3.14 -> xyz=0 0 0.195722 rpy=0 0 0
